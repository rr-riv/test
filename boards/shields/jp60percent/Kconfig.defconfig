## boards/shields/jp60percent/Kconfig.defconfig
```kconfig
if SHIELD_JP60PERCENT

config ZMK_KEYBOARD_NAME
    default "jp60percent"

endif
```
